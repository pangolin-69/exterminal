DESCRIPTION = "Go Terminal Example"
SRC_URI = "git://github.com/https://github.com/pangolin-69/exterminal"
SRCREV = "e500bf94d187159f3f43a7a8785756fcedc1c967"

LICENSE = "CLOSED"
inherit go-mod
GO_IMPORT = "exterminal"